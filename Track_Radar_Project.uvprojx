# Keil uVision project Track_Radar_Project.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Track_Radar_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\FreeRTOS Workspace;..\..\FreeRTOS Workspace\Include;..\..\FreeRTOS Workspace\Portable\GCC\ARM_CM4F;..\..\FreeRTOS Workspace\Portable\MemMang;..\..\GNSS Lib\lib-keil;..\010Track_Radar_Software;..\..\Lora Libs\RA-02 Lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c Req.h GPIO.c RCC.c USART.c Delay.c Req.c I2C.c SPI.c TIM4.c PWM.c Control.c
  group FreeRTOS
    ../../FreeRTOS Workspace/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_GCC
    ../../FreeRTOS Workspace/Portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS_MemMang
    ../../FreeRTOS Workspace/Portable/MemMang/: heap_4.c
  group LoRa-RA02
    ../../../Documents/Lora Libs/RA-02 Lib/: LoRa.c LoRa.h
  group GNSS
    ../../GNSS Lib/lib-keil/: M-GPS.c M-GPS.h M-GPS-Test.c
  group Angular Encoder
    ./: as5048b.c as5048b.h
  group LoRa-RA08H
    ./: RA_08h.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
